# Keil uVision project HUST-RM-Master.uvprojx, settings and files
target HUST-RM-Master (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HUST-RM-Master
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx, ARM_MATH_CM4, __FPU_PRESENT=1, __FPU_USED =1, __CC_ARM
  c include: ..\User;..\Task;..\Mylib;..\Library\inc;..\Library\CMSIS;..\FreeRTOS\include;..\FreeRTOS\port\RVDS\ARM_CM4F;..\Algorithm;..\Algorithm;..\Task;..\RTOS_Test;..\INS;..\SEGGER_RTT_V784\RTT;..\SEGGER_RTT_V784\Config;..\SD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c stm32f4xx_it.c system_stm32f4xx.c startup_stm32f40_41xxx.s FreeRTOSConfig.h arm_cortexM4lf_math.lib
  group Library
    ../Library/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_dbgmcu.c stm32f4xx_spi.c
    ../Library/CMSIS/: arm_cortexM4lf_math.lib arm_math.h
  group Mylib
    ../Mylib/: can1.c can2.c FrictionWheel.c iwdg.c MicroSw.c SteeringEngine.c tim4.c usart1.c laser.c gpio.c usart3.c counter.c pc_serial.c pc_uart.c
    ../Task/: usart4_gryo.c
    ../RTOS_Test/: os_tick.c
    ../SD/: bsp_spi_sdcard.c
  group Algorithm
    ../Algorithm/: pid.c algorithmOfCRC.c TD.c user_lib.c queueData.c
    ../Mylib/: MySensors.c
  group Task
    ../Task/: ChassisTask.c DataReceiveTask.c DataSendTask.c ZeroCheckTask.c ShootTask.c GimbalTask.c ActionTask.c Start_Task.c ControlTask.c
    ../RTOS_Test/: CPU_Task.c
    ../INS/: GimbalEstimateTask.c
    ../SD/: SDCardTask.c
  group FreeRTOS/src
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../FreeRTOS/port/MemMang/: heap_4.c
    ../FreeRTOS/port/RVDS/ARM_CM4F/: port.c
  group Tool
    ../INS/: debug.c RtosTaskCheck.c
  group RTOS_Test
    ../RTOS_Test/: tools.c
    ../SEGGER_RTT_V784/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group INS
    ../INS/: icm20602.c ins.c kalman_filter.c QuaternionEKF.c
  group SD
    ../SD/: diskio.c ff.c
