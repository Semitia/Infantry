# Keil uVision project Infantry_S.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Infantry_S
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx, MATH_CM4,__FPU_PRESENT=1,__FPU_USED =1, ARM_MATH_CM4, __CC_ARM
  c include: ..\User;..\Mylib;..\Library\CMSIS;..\Library\inc;..\Library\src;..\Task;..\Mylib;..\FreeRTOS\src;..\FreeRTOS\port\MemMang;..\FreeRTOS\port\RVDS\ARM_CM4F;..\FreeRTOS\include;..\Algorithm;..\Hardware;..\Software;..\Task
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c FreeRTOSConfig.h sys.c
  group Library
    ../Library/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_rcc.c stm32f4xx_dac.c stm32f4xx_iwdg.c stm32f4xx_spi.c stm32f4xx_dbgmcu.c
    ../Library/CMSIS/: startup_stm32f40_41xxx.s
  group FreeRTOS/Src
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Port
    ../FreeRTOS/port/MemMang/: heap_4.c
    ../FreeRTOS/port/RVDS/ARM_CM4F/: port.c
  group Hardware
    ../Hardware/: adc.c can1.c can2.c counter.c dac.c i2c.c ina260.c iwdg.c tim2.c uart4.c usart2.c cap.c usart1.c
    ../Mylib/: tim.c
  group Algorithm
    ../Algorithm/: algorithmOfCRC.c pid.c filters.c myMath.c tool.c Matrix.c RLS.c
  group Software
    ../Software/: motor.c Chassis.c Kinematic.c Power.c JudgeMsg.c Usart.c Can.c CanRing.c
  group Tasks
    ../Task/: Start_Task.c ChassisTask.c
